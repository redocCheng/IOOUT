# Keil uVision project ioout.uvprojx, settings and files
target ioout (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ioout +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6
  c misc: --C99
  c include: ..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;..\..\Drivers/CMSIS/Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\user;..\hardware;..\..\..\ioout
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group document
    ../document/: updataLog.txt
  group drivers/cmsis
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103x6.s
  group drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c
  group ioout
    ../../../ioout/: ioout.c
  group user
    ../user/: main.c stm32f1xx_it.c
  group hardware
    ../hardware/: bsp.c gpio.c tim.c
software components: CMSIS:CORE 3.40.0
